# Keil uVision project blinky.uvproj, settings and files
target nRF51822 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: blinky_arm +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 SETUPA BOARD_PCA10001 FLASH_TEST
  c misc: --c99
  c include: ..\..\..\..\Include;.\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ./: main.c
  group core
    ./: system_nrf51.c arm_startup_nrf51.s
  group lib
    ./: nrf_delay.c nrf_lcd.c font.c flash.c
target nRF51822_S110 (ARM-ADS)
  device: nRF51 Nordic
  cpu: as above
  output: blinky_arm_s110 +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51 SETUPA BOARD_PCA10001
  c misc: --c99
  c include: ..\..\..\..\Include
  library: MicroLIB
  memory RVCT4: ROM 0x20000 size 0x20000
  memory RVCT9: RAM 0x20002000 size 0x2000
